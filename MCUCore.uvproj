# Keil uVision project MCUCore.uvproj, settings and files
target MCUCore (MCS-51)
  device: SH68F86 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) CLOCK(12000000)
  output: MCUCore +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: .\header;.\roidmi\inc
  group User
    ./code/: Main.c Initial.c Interrupt.c AfeProcess.c Balance.c Calibrate.c Calculate.c ShutDown.c Uart.c Led.c Memory.c Key.c
  group Driver
    ./code/: STARTUP.A51 GasGauge.c RTC.c ExtE2PRom.c McuFlash.c AfeMtp.c TwiIO.c TwiModule.c Common.c
  group Roidmi
    ./roidmi/src/: protect.c process.c adc.c funckey.c
  group ISP
    ./code/: ISP.c
  group Header
    ./header/: Main.h Calibrate.h Uart.h Led.h Memory.h c51_type.h GasGauge.h ExtE2PRomRTC.h McuFlash.h AfeMtp.h TwiIO.h TwiModule.h Common.h System.h SH79F6441.h ISP.h Key.h
  group EEPROM
    ./code/: DataFlash.c
target Eeprom (MCS-51)
  device: SH79F1612B Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0-0x2FF) CLOCK(16600000)
  output: Eeprom +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\header;.\roidmi\inc
